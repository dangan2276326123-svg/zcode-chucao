# Keil uVision project PWM.uvprojx, settings and files
target PWM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: PWM +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE\BEEP;..\HARDWARE\CAN;..\HARDWARE\car_cotrol;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\path_plan;..\HARDWARE\senor;..\HARDWARE\telecontrol;..\HARDWARE\work_control;..\HARDWARE\ADC;..\HARDWARE\UART3;..\HARDWARE\CRC;..\HARDWARE\uart2;..\HARDWARE\uart5;..\HARDWARE\uart4;..\HARDWARE\bujin_motor;..\HARDWARE\DRIVER;..\HARDWARE\IWDG;..\HARDWARE\iic;..\HARDWARE\UART3;..\HARDWARE\retrofit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/path_plan/: path_plan.c
    ../HARDWARE/senor/: sensor.c
    ../HARDWARE/telecontrol/: telecontrol.c
    ../HARDWARE/work_control/: work_control.c
    ../HARDWARE/CRC/: CRC2.c
    ../HARDWARE/uart5/: uart5.c
    ../HARDWARE/uart2/: uart2.c
    ../HARDWARE/uart4/: uart4.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/iic/: iic.c
    ../HARDWARE/UART3/: uart3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_iwdg.c
  group README
    ../: readme.txt
  group RETROFIT
    ../HARDWARE/retrofit/: protocol.c retrofit.c
